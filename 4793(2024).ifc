Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8ded863a-fef2-49e7-b83e-72eb26fb6669, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 4793(2024).ifc
Time: 2025-01-29T22:00:51
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_377212_1
InPort_377212_3

# IfcFlowController: 4793(2024):4793 Shower system, 4793(2024):4793 Shower system:377212
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 4793(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1111, EN 1112, EN 1113; ETIM Class Number: EC011329 Shower mixing tap; LVI Number: 6310922; Noise Class: I (ISO 3822); NRF Number: 1365175; RSK Number: 8283482; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/4793; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/198292_4793_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/4793; VVS Number: 722260804
Type - Constraints - Default Elevation: 0 mm; ShowerDefaultElevation: 800 mm
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Anti-twist hose connector; Aerator: Standard aerator; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread;Cover plate(s); Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.16 dm3/s; Flow Rate At 300kPa: 0.32 dm3/s; Hand Shower Size: Ø 110 mm; Installation Type: Wall mounted; Installation Width: 150 ± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Eco feature for water flow; Max. Hot Water Supply: 65 C; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Over Head Shower Size: Ø 300 mm; Pressure Loss With Flow 02ls: 195000 Pa; Pressure Loss With Flow 03ls: 270000 Pa; Shower Parts: Hand shower;Shower rail;Swivel overhead shower;Lockable in the middle position;Adjustable shower rail bracket;Shower hose (1750 mm);Variable fixing points;Rotatable ball joint connection;Anti limescale technology (easy to clean);Twist guard for shower hose; Shower Spray: Pulsating - Strong water stream for massage or body treatment;Intense - invigorating water stream;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Spout Projection: 180 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Construction - Type: 0 mm
Type - Dimensions - NominalDepth: 634 mm; NominalHeight: 1233.6 mm; NominalWidth: 300 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/4793; Catalog Drawing URL: http://static.oras.com/catdrw/4793; Category B2C: Shower solutions; Color variants: 4793-33;4793-81;4793-80; Dimension Drawing URL: http://static.oras.com/dimdrw/4793; FDV Document URL: http://www.oras.com/datasheet/4793/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4793; Group: Shower system; Installation and Maintenance Guide URL: http://static.oras.com/manual/4793; Interactive AR View URL: https://static.oras.com/AR/4793; Long Marketing: Oras Aurelia A Harmony of Simplicity and Elegance. The design of Oras Aurelia is characterized by pure, fluid shapes—timeless in their simplicity yet subtly complex in execution. This results in a delicate dance between the straightforward and the intricate, visually capturing nature's own balance. Stand beneath the cascading water to experience a symphony of sensations, as clever design ensures efficient water distribution, embracing the complete body in refreshing and rejuvenating comfort. Elevate your daily ritual with Oras Aurelia, where every drop becomes a celebration of inherent beauty. 1-spray, Ø300 overhead shower 3-spray Ø110 hand shower 1750mm hose ELEVATING YOUR MOMENTS; Manufacturer: Oras; Market: International;Norway;Sweden;Denmark;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/4793; Model: 4793 Shower system; Name_en: 4793 Shower system; OmniClass Number: 23.45.55.00; Product Code: 4793; Product Family: Oras Aurelia; Product Image URL: http://static.oras.com/image/4793; Product URL: http://static.oras.com/4793; Spare-Part Information URL: http://static.oras.com/sp/4793; Technical DataSheet URL: http://www.oras.com/datasheet/4793/en; Type Name: 4793 Shower system; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4793(2024); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 4793; Name: 4793 Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 290x545x1165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 4793; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 4793 Shower system
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>, Chrome
Pset_DistributionFlowElementCommon - Reference: 4793 Shower system; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 1.34556 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.234554 m3
Identity Data - Mark: 10
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 4793(2024); Family and Type: 4793(2024): 4793 Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4793 Shower system; Type Id: 377190; WarrantyStartDate: n/a
